Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView_V2.0]
File name: 0001
Time: 2024-04-17T16:18:14
Written by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013
Made in: 20200210_1400(x64) - Exporter 20.2.12.1 - Alternate UI 20.2.12.1
Comment: STEP Physical File produced by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013 * Module: EDMstepFileFactory/EDMstandAlone * Creation date: Wed Apr 17 16:18:14 2024 * Host: DESKTOP-BQGE6H4 * Database: C:\Users\Avocado\AppData\Local\Temp\ea6a3546-6f2f-4ac4-9634-df962f674959\e4a582ee-b352-47d1-843b-ad39825d34ad\ifc * Database version: 5507 * Database creation date: Wed Apr 17 16:18:12 2024 * Schema: IFC2X3 * Model: DataRepository.ifc * Model creation date: Wed Apr 17 16:18:12 2024 * Header model: DataRepository.ifc_HeaderModel * Header model creation date: Wed Apr 17 16:18:12 2024 * EDMuser: sdai-user * EDMgroup: sdai-group * License ID and type: 5605 : Permanent license. Expiry date: * EDMstepFileFactory options: 020000

# IfcProject, 0001
LongName: Project Name; Phase: Project Status

# IfcSite, Default
RefLatitude: 42, 21, 31, 181945; RefLongitude: -71, -3, -24, -263305; RefElevation: 0 mm
Other - Category: Project Information; Client Name: Owner; Project Address: Enter address here; Project Issue Date: Issue Date; Project Name: Project Name; Project Number: 0001; Project Status: Project Status

# IfcBuilding
Pset_BuildingCommon - NumberOfStoreys: 1
Pset_ProductRequirements - Category: Project Information
Other - Category: Project Information; Client Name: Owner; Project Address: Enter address here; Project Issue Date: Issue Date; Project Name: Project Name; Project Number: 0001; Project Status: Project Status

# IfcBuildingStorey: Level:8mm Head, Level 1
LongName: Level 1; Elevation: 0 mm
Other(Type) - Category: Levels; Family Name: Level
Identity Data(Type) - Type Name: 8mm Head
Pset_AirSideSystemInformation - Name: Level 1
Pset_ProductRequirements - Name: Level 1; Category: Levels
Constraints - Elevation: 0 mm
Dimensions - Computation Height: 0 mm
Identity Data - Building Story: yes; Name: Level 1; Structural: no
Other - Category: Levels; Family: Level: 8mm Head; Family and Type: Level: 8mm Head; Type: Level: 8mm Head; Type Id: Level: 8mm Head
Constraints(Type) - Elevation Base: Project Base Point
Graphics(Type) - Color: 0; Line Pattern: Centre; Line Weight: 1; Symbol: M_Level Head - Circle: M_Level Head - Circle; Symbol at End 1 Default: no; Symbol at End 2 Default: yes

# IfcFurnishingElement: Armchair 45 - Linen webbing, Artek-Chairs-Armchair-45_rfa:Armchair 45 - Linen webbing:506427
In: Level 1
Type - Material: Clear lacquered, Natural black linen webbing
Type - Constraints - Default Elevation: 0 mm
Type - Construction - ArmrestType: Armchair-45_Armrest_None; SeatType: Armchair-45_Linen
Type - Dimensions - NominalDepth: 639.243 mm; NominalHeight: 834.411 mm; NominalLength: 556 mm
Type - General - Author: BIMstone; BIMObjectName: Artek-Chairs-Armchair-45_rfa; ManufacturerName: Arket; ManufacturerURL: https://www.artek.fi/; NBSDescription: Domestic chairs; NBSReference: 45-35-20/365; ProductInformation: n/a; Revision: n/a; Uniclass2: Pr_40_50_12_48; Uniclass2015Description: Dining chairs; Uniclass2015Reference: Pr_40_50_12_22; Version: 1; VersionDate: 15/04/2024
Type - Identity Data - Cost: 0; Manufacturer: Artek; Model: Armchair 45 - Linen webbing; OmniClass Number: 23.40.20.14.14.11; OmniClass Title: Chairs; Type Name: Armchair 45 - Linen webbing; URL: https://www.artek.fi/en/products/chairs
Type - Other - Category: Furniture; AccessibilityPerformance: n/a; AssetType: Movable; Brand: Artek; CodePerformance: n/a; Color: Various; Constituents: n/a; DurationUnit: Year; ExpectedLife: n/a; Family Name: Artek-Chairs-Armchair-45_rfa; Features: n/a; Finish: n/a; Grade: n/a; ModelNumber: n/a; ModelReference: n/a; Name: Armchair-45_rfa; ReplacementCost: n/a; Shape: Sculptured; Size: 555x640x835 mm; SustainabilityPerformance: n/a; WarrantyDescription: n/a; WarrantyDurationLabor: n/a; WarrantyDurationParts: n/a; WarrantyDurationUnit: Year; WarrantyGuarantorLabor: n/a; WarrantyGuarantorParts: n/a
Type - Pset_ElementShading - Color: Various
Type - Pset_ManufacturerTypeInformation - ModelReference: n/a; Manufacturer: Artek
Type - Pset_ProductRequirements - Name: Armchair-45_rfa; Category: Furniture
Type - Pset_QuantityTakeOff - Reference: Armchair 45 - Linen webbing
Pset_ManufacturerOccurrence - BarCode: n/a; SerialNumber: n/a
Constraints - Elevation from Level: 0 mm; Host: Level : Level 1; Level: Level: Level 1; Moves With Nearby Elements: no; Offset from Host: 0 mm
Dimensions - Area: 1.35114 m2; Volume: 0.296087 m3
Materials and Finishes - ChairMainMaterial: Natural black linen webbing; ChairSecondaryMaterial: Natural black linen webbing; ChairTertiaryMaterial: Clear lacquered
Other - AssetIdentifier: n/a; Barcode: n/a; Family: Artek-Chairs-Armchair-45_rfa: Armchair 45 - Linen webbing; Family and Type: Artek-Chairs-Armchair-45_rfa: Armchair 45 - Linen webbing; InstallationDate: n/a; Material: Wood & textile; SerialNumber: n/a; TagNumber: n/a; Type: Artek-Chairs-Armchair-45_rfa: Armchair 45 - Linen webbing; Type Id: Artek-Chairs-Armchair-45_rfa: Armchair 45 - Linen webbing; WarrantyStartDate: n/a
Phasing - Phase Created: New Construction
